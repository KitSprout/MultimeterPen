# Keil uVision project ProjSTM32.uvprojx, settings and files
target STM32L011 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L011F4Px STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L011 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L011xx
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32L0xx_HAL_Driver\Inc;..\Libraries\STM32L0xx_HAL_Driver\Inc\Legacy;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32l011xx.s system_stm32l0xx.c
  group Library
    ../Libraries/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_rcc.c stm32l0xx_hal_adc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_tim.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
    ../Program/: stm32l0xx_hal_conf.h
  group Driver
    ../Program/drivers/: stm32l0_msp.c stm32l0_delay.c stm32l0_adc.c stm32l0_tim.c stm32l0_uart.c stm32l0_i2cSimu.c stm32x_system.h
    ../Program/: boardConfig.h
  group Program
    ../Program/: main.c stm32x_bsp.c stm32l0xx_it.c
  group Module
    ../Program/modules/: serial.c ssd1306.c font.c
